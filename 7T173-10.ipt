# Autodesk Inventor part: 7T173-10
## iProperties
Created: 2008-09
Part Number: 7T173-10
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
